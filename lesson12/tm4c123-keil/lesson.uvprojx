# Keil uVision project lesson.uvprojx, settings and files
target Debug (6230000::V6.23::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: lesson
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c misc: -Wno-declaration-after-statement
  c include: ..\ek-tm4c123gxl
  asm define: Stack_Size=2048,Heap_Size=0
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: lesson.sct
  group Source
    ./: main.c delay.c
  group ek-tm4c123gxl
    ../ek-tm4c123gxl/arm/: startup_TM4C123GH6PM.s
    ../ek-tm4c123gxl/: system_TM4C123GH6PM.c
software components: CMSIS:CORE 6.1.0
